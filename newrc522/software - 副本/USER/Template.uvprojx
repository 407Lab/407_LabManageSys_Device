# Keil uVision project Template.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FATFS\exfuns;..\FATFS\src;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\RC522;..\HARDWARE\SDIO;..\HARDWARE\DS1302;..\HARDWARE\BEEP;..\HARDWARE\HC05;..\HARDWARE\TIMER;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RC522/: rc522.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/DS1302/: ds1302.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group MALLOC
    ../MALLOC/: malloc.c
